require linux-yocto-intel-socfpga.inc

KBRANCH_intel-socfpga-64 = "v5.2/standard/intel-sdk-5.4/intel-socfpga"

LINUX_VERSION_intel-socfpga-64 ?= "5.2.x"
